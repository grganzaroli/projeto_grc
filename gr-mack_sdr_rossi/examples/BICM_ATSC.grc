<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>author</key><value>Guilherme Rossi Ganzaroli</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>BICM ATSC 3.0 </value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>n_bch</value></param>
<param><key>value</key><value>10800</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>n_ldpc</value></param>
<param><key>value</key><value>16200</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>r</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>bch_dec</key>
<param><key>id</key><value>bch_dec_0</value></param>
<param><key>n</key><value>10800</value></param>
</block>
<block>
<key>bch_enc</key>
<param><key>id</key><value>bch_enc_0</value></param>
<param><key>n</key><value>n_bch</value></param>
</block>
<block>
<key>block_deinter</key>
<param><key>id</key><value>block_deinter_0</value></param>
<param><key>n</key><value>n_ldpc</value></param>
</block>
<block>
<key>block_inter</key>
<param><key>id</key><value>block_inter_0</value></param>
<param><key>n</key><value>n_ldpc</value></param>
</block>
<block>
<key>blocks_float_to_char</key>
<param><key>id</key><value>blocks_float_to_char_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0</value></param>
<param><key>high</key><value>0.5</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>0.5</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0</value></param>
<param><key>epsilon</key><value>1.0</value></param>
<param><key>freq_offset</key><value>0.0</value></param>
<param><key>noise_voltage</key><value>0.15</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>taps</key><value>1.0 + 1.0j</value></param>
</block>
<block>
<key>demapper_atsc</key>
<param><key>id</key><value>demapper_atsc_0</value></param>
<param><key>m</key><value>6</value></param>
<param><key>r</key><value>10</value></param>
<param><key>n</key><value>n_ldpc</value></param>
</block>
<block>
<key>gw_deinter</key>
<param><key>id</key><value>gw_deinter_0</value></param>
<param><key>n</key><value>n_ldpc</value></param>
</block>
<block>
<key>gw_inter</key>
<param><key>id</key><value>gw_inter_0</value></param>
<param><key>n</key><value>n_ldpc</value></param>
</block>
<block>
<key>ldpc_dec</key>
<param><key>id</key><value>ldpc_dec_0</value></param>
<param><key>r</key><value>10</value></param>
<param><key>n</key><value>16200</value></param>
</block>
<block>
<key>ldpc_enc</key>
<param><key>id</key><value>ldpc_enc_0</value></param>
<param><key>r</key><value>r</value></param>
<param><key>n</key><value>n_ldpc</value></param>
</block>
<block>
<key>mapper_atsc</key>
<param><key>id</key><value>mapper_atsc_0</value></param>
<param><key>m</key><value>6</value></param>
<param><key>r</key><value>10</value></param>
<param><key>n</key><value>n_ldpc</value></param>
</block>
<block>
<key>mapper_prbs_sink_b</key>
<param><key>id</key><value>mapper_prbs_sink_b_0</value></param>
<param><key>which_mode</key><value>"PRBS7"</value></param>
<param><key>reset_len</key><value>162000</value></param>
</block>
<block>
<key>mapper_prbs_source_b</key>
<param><key>id</key><value>mapper_prbs_source_b_0</value></param>
<param><key>which_mode</key><value>"PRBS7"</value></param>
<param><key>reset_len</key><value>162000</value></param>
</block>
<block>
<key>parity_deinter</key>
<param><key>id</key><value>parity_deinter_0</value></param>
<param><key>n</key><value>n_ldpc</value></param>
</block>
<block>
<key>parity_inter</key>
<param><key>id</key><value>parity_inter_0</value></param>
<param><key>n</key><value>n_ldpc</value></param>
</block>
<connection><source_block_id>bch_dec_0</source_block_id><sink_block_id>mapper_prbs_sink_b_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>bch_enc_0</source_block_id><sink_block_id>ldpc_enc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>block_deinter_0</source_block_id><sink_block_id>gw_deinter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>block_inter_0</source_block_id><sink_block_id>mapper_atsc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_char_0</source_block_id><sink_block_id>ldpc_dec_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>blocks_float_to_char_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>demapper_atsc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>demapper_atsc_0</source_block_id><sink_block_id>block_deinter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gw_deinter_0</source_block_id><sink_block_id>parity_deinter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gw_inter_0</source_block_id><sink_block_id>block_inter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ldpc_dec_0</source_block_id><sink_block_id>bch_dec_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ldpc_enc_0</source_block_id><sink_block_id>parity_inter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mapper_atsc_0</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mapper_prbs_source_b_0</source_block_id><sink_block_id>bch_enc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>parity_deinter_0</source_block_id><sink_block_id>blocks_threshold_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>parity_inter_0</source_block_id><sink_block_id>gw_inter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
