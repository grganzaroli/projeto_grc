<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>author</key><value>Guilherme Rossi Ganzaroli</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>BICM ATSC 3.0 </value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mod_size</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>n_bch</value></param>
<param><key>value</key><value>n_ldpc*r/15</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>n_ldpc</value></param>
<param><key>value</key><value>64800</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>r</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>max</key><value>2</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>1000000</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>bch_dec</key>
<param><key>id</key><value>bch_dec_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>fec</key><value>10</value></param>
<param><key>size</key><value>64800</value></param>
</block>
<block>
<key>bch_enc</key>
<param><key>id</key><value>bch_enc_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>fec</key><value>10</value></param>
<param><key>size</key><value>64800</value></param>
</block>
<block>
<key>bl_inter</key>
<param><key>id</key><value>bl_inter_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>mod</key><value>mod_size</value></param>
<param><key>r</key><value>r</value></param>
<param><key>n</key><value>n_ldpc</value></param>
</block>
<block>
<key>blks2_error_rate</key>
<param><key>id</key><value>blks2_error_rate_0</value></param>
<param><key>bits_per_symbol</key><value>1</value></param>
<param><key>type</key><value>'BER'</value></param>
<param><key>win_size</key><value>1000000</value></param>
</block>
<block>
<key>block_deinter</key>
<param><key>id</key><value>block_deinter_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>mod</key><value>mod_size</value></param>
<param><key>r</key><value>r</value></param>
<param><key>n</key><value>n_ldpc</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_float_to_char</key>
<param><key>id</key><value>blocks_float_to_char_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>high</key><value>0</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>0</value></param>
</block>
<block>
<key>demapper_atsc</key>
<param><key>id</key><value>demapper_atsc_0</value></param>
<param><key>m</key><value>mod_size</value></param>
<param><key>r</key><value>r</value></param>
<param><key>size_in</key><value>1</value></param>
</block>
<block>
<key>group_deinter</key>
<param><key>id</key><value>group_deinter_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>mod</key><value>mod_size</value></param>
<param><key>r</key><value>r</value></param>
<param><key>n</key><value>n_ldpc</value></param>
</block>
<block>
<key>gw_inter</key>
<param><key>id</key><value>gw_inter_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>mod</key><value>mod_size</value></param>
<param><key>r</key><value>r</value></param>
<param><key>n</key><value>n_ldpc</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>ldpc_dec</key>
<param><key>id</key><value>ldpc_dec_0</value></param>
<param><key>r</key><value>r</value></param>
<param><key>n</key><value>n_ldpc</value></param>
</block>
<block>
<key>ldpc_dec_soft</key>
<param><key>id</key><value>ldpc_dec_soft_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>r</key><value>r</value></param>
<param><key>n</key><value>n_ldpc</value></param>
</block>
<block>
<key>ldpc_enc</key>
<param><key>id</key><value>ldpc_enc_0</value></param>
<param><key>r</key><value>r</value></param>
<param><key>n</key><value>n_ldpc</value></param>
</block>
<block>
<key>mapper_atsc</key>
<param><key>id</key><value>mapper_atsc_0</value></param>
<param><key>m</key><value>mod_size</value></param>
<param><key>r</key><value>r</value></param>
<param><key>n</key><value>n_ldpc</value></param>
</block>
<block>
<key>par_inter</key>
<param><key>id</key><value>par_inter_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>r</key><value>r</value></param>
<param><key>n</key><value>n_ldpc</value></param>
</block>
<block>
<key>parity_deinter</key>
<param><key>id</key><value>parity_deinter_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>r</key><value>r</value></param>
<param><key>n</key><value>n_ldpc</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>avg</key><value>0.5</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_NONE</value></param>
<param><key>type</key><value>float</value></param>
<param><key>factor1</key><value>1e6</value></param>
<param><key>label1</key><value>BER</value></param>
<param><key>unit1</key><value>x10-6</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>OUT</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>1.1</value></param>
<param><key>ymin</key><value>-0.1</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>IN</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>1.1</value></param>
<param><key>ymin</key><value>-0.1</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_1</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>OUT DEINTERLEAVERS</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>1.1</value></param>
<param><key>ymin</key><value>-0.1</value></param>
</block>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>bch_enc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>blks2_error_rate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>blocks_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>bch_dec_0</source_block_id><sink_block_id>blks2_error_rate_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>bch_dec_0</source_block_id><sink_block_id>blocks_char_to_float_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>bch_enc_0</source_block_id><sink_block_id>ldpc_enc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>bl_inter_0</source_block_id><sink_block_id>mapper_atsc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_error_rate_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>block_deinter_0</source_block_id><sink_block_id>group_deinter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_char_0</source_block_id><sink_block_id>bch_dec_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>blocks_float_to_char_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>demapper_atsc_0</source_block_id><sink_block_id>block_deinter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>group_deinter_0</source_block_id><sink_block_id>parity_deinter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gw_inter_0</source_block_id><sink_block_id>bl_inter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ldpc_dec_0</source_block_id><sink_block_id>bch_dec_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ldpc_dec_soft_0</source_block_id><sink_block_id>bch_dec_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ldpc_enc_0</source_block_id><sink_block_id>par_inter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mapper_atsc_0</source_block_id><sink_block_id>demapper_atsc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mapper_atsc_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>par_inter_0</source_block_id><sink_block_id>gw_inter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>parity_deinter_0</source_block_id><sink_block_id>blocks_threshold_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>parity_deinter_0</source_block_id><sink_block_id>ldpc_dec_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>parity_deinter_0</source_block_id><sink_block_id>ldpc_dec_soft_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>parity_deinter_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
