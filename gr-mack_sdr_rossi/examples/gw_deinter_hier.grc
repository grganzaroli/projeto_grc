<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>group_deinter</value></param>
<param><key>author</key><value>Guilherme Rossi Ganzaroli</value></param>
<param><key>category</key><value>[MACK_SDR_ROSSI]</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>Group-Wise Deinterleaver</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>n</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>n</value></param>
</block>
<block>
<key>mack_sdr_rossi_Group_deinterleaver_ATSC</key>
<param><key>id</key><value>mack_sdr_rossi_Group_deinterleaver_ATSC_0</value></param>
<param><key>Mod_size</key><value>mod</value></param>
<param><key>Nldpc</key><value>n</value></param>
<param><key>Rate</key><value>r</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>mod</value></param>
<param><key>label</key><value>Mod_size</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>n</value></param>
<param><key>label</key><value>Size</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>r</value></param>
<param><key>label</key><value>Rate</value></param>
<param><key>value</key><value>10</value></param>
</block>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>mack_sdr_rossi_Group_deinterleaver_ATSC_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mack_sdr_rossi_Group_deinterleaver_ATSC_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
