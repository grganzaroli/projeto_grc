<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>bch_enc</value></param>
<param><key>author</key><value>Guilherme Rossi Ganzaroli</value></param>
<param><key>category</key><value>[MACK_SDR_ROSSI]</value></param>
<param><key>description</key><value>BCH encoder ATSC 3.0</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>BCH Encoder</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>controle</value></param>
<param><key>value</key><value>((eq/abs(eq))+1)/2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>eq</value></param>
<param><key>value</key><value>size-30000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>n</value></param>
<param><key>value</key><value>size*fec/15</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>paridade</value></param>
<param><key>value</key><value>[168 ,192]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>n-paridade[controle]</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>n</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fec</value></param>
<param><key>label</key><value>Rate</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>mack_sdr_rossi_BCH_encoder_ATSC</key>
<param><key>id</key><value>mack_sdr_rossi_BCH_encoder_ATSC_0</value></param>
<param><key>K</key><value>n-paridade[controle]</value></param>
<param><key>N</key><value>n</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>bit</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>bit</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>size</value></param>
<param><key>label</key><value>Size</value></param>
<param><key>value</key><value>64800</value></param>
</block>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>mack_sdr_rossi_BCH_encoder_ATSC_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mack_sdr_rossi_BCH_encoder_ATSC_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
