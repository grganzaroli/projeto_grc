<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>mapper_atsc</value></param>
<param><key>author</key><value>Guilherme Rossi Ganzaroli</value></param>
<param><key>category</key><value>[MACK_SDR_ROSSI]</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>Mapper</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>int(math.sqrt(mod))-5</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_pack_k_bits_bb</key>
<param><key>id</key><value>blocks_pack_k_bits_bb_0</value></param>
<param><key>k</key><value>int(math.sqrt(mod))</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>mack_sdr_rossi_Mapper_ATSC</key>
<param><key>id</key><value>mack_sdr_rossi_Mapper_ATSC_0</value></param>
<param><key>Mod_size</key><value>mod</value></param>
<param><key>N_ldpc</key><value>n</value></param>
<param><key>Rate</key><value>r</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>mod</value></param>
<param><key>label</key><value>Mod_size</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>n</value></param>
<param><key>label</key><value>Size</value></param>
<param><key>value</key><value>10800</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>bit</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>r</value></param>
<param><key>label</key><value>Rate</value></param>
<param><key>value</key><value>10</value></param>
</block>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pack_k_bits_bb_0</source_block_id><sink_block_id>mack_sdr_rossi_Mapper_ATSC_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mack_sdr_rossi_Mapper_ATSC_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_pack_k_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
