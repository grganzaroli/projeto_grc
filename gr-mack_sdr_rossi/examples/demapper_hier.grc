<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>demapper_atsc</value></param>
<param><key>author</key><value>Guilherme Rossi Ganzaroli</value></param>
<param><key>category</key><value>[MACK_SDR_ROSSI]</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>Demapper</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>size_out</value></param>
<param><key>value</key><value>int(1*math.log(m)/math.log(2)*size_in)</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>size_in</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>size_out</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>m</value></param>
<param><key>label</key><value>Modulação</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>mack_sdr_rossi_Demapper_ATSC</key>
<param><key>id</key><value>mack_sdr_rossi_Demapper_ATSC_0</value></param>
<param><key>mod_size</key><value>m</value></param>
<param><key>rate</key><value>r</value></param>
<param><key>size_in</key><value>size_in</value></param>
<param><key>size_out</key><value>size_out</value></param>
<param><key>var</key><value>0.01</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>r</value></param>
<param><key>label</key><value>Rate</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>size_in</value></param>
<param><key>label</key><value>Size</value></param>
<param><key>value</key><value>1</value></param>
</block>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>mack_sdr_rossi_Demapper_ATSC_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mack_sdr_rossi_Demapper_ATSC_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
